# Keil uVision project emwin_gui_demo.uvprojx, settings and files
target emwin_gui_demo sdram_debug (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: emwin_gui_demo.out
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: SKIP_SYSCLK_INIT, DEBUG, CPU_MIMXRT1052DVL6B
  c misc: --library_interface=armcc --diag_suppress=66,1296,186 --diag_suppress=1296,186
  c include: ..;../../..;../../../../../CMSIS/Include;../../../../../devices;../../../../../middleware/emwin/emWin_Config;../../../../../middleware/emwin/emWin_header;../../../../../devices/MIMXRT1052/drivers;../../../../../devices/MIMXRT1052/drivers;../../../../../devices/MIMXRT1052/drivers;../../../../../components/ft5406_rt;../../../../../devices/MIMXRT1052/drivers;../../../../../devices/MIMXRT1052/drivers;../../../../../devices/MIMXRT1052;../../../../../devices/MIMXRT1052/utilities/str;../../../../../devices/MIMXRT1052/utilities/debug_console;../../../../../components/uart;../../../../../components/serial_manager;../../../../../components/serial_manager;../../../../../devices/MIMXRT1052/drivers;../../../../../components/lists;../../../../../devices/MIMXRT1052/drivers;../../../../../devices/MIMXRT1052/drivers;../../../../../devices/MIMXRT1052/xip;../../../xip
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1052xxxxx_sdram.scf
  link misc: ../../../../../middleware/emwin/emWin_library/Keil/emWin_M4F.lib --remove
  group source
    ../: awtk_gui_demo.c
  group board
    ../: pin_mux.c pin_mux.h emwin_support.c emwin_support.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MIMXRT1052/drivers/: fsl_elcdif.c fsl_elcdif.h fsl_pxp.c fsl_pxp.h fsl_lpi2c.c fsl_lpi2c.h fsl_common.c fsl_common.h fsl_clock.c fsl_clock.h fsl_lpuart.c fsl_lpuart.h fsl_iomuxc.h fsl_gpio.c fsl_gpio.h
  group touchpanel
    ../../../../../components/ft5406_rt/: fsl_ft5406_rt.c fsl_ft5406_rt.h
  group device
    ../../../../../devices/MIMXRT1052/: MIMXRT1052.h MIMXRT1052_features.h fsl_device_registers.h system_MIMXRT1052.c system_MIMXRT1052.h
  group utilities
    ../../../../../devices/MIMXRT1052/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MIMXRT1052/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MIMXRT1052/utilities/: fsl_assert.c
  group component-uart
    ../../../../../components/uart/: lpuart_adapter.c uart.h
  group component-serial_manager
    ../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group component-lists
    ../../../../../components/lists/: generic_list.c generic_list.h
  group startup
    ../../../../../devices/MIMXRT1052/arm/: startup_MIMXRT1052.s
  group xip
    ../../../../../devices/MIMXRT1052/xip/: fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
    ../../../xip/: evkbimxrt1050_flexspi_nor_config.c evkbimxrt1050_flexspi_nor_config.h evkbimxrt1050_sdram_ini_dcd.c evkbimxrt1050_sdram_ini_dcd.h
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm7.h arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv8mbl.h core_armv8mml.h mpu_armv7.h mpu_armv8.h
  group awtk-src
    ../../../../../middleware/awtk-1.3/src/: awtk.h awtk_base.h awtk_ext_widgets.h awtk_global.c awtk_global.h awtk_tkc.h awtk_widgets.h
  group awtk-src-base
    ../../../../../middleware/awtk-1.3/src/base/: assets_manager.c assets_manager.h awtk_config_sample.h bitmap.c bitmap.h canvas.c canvas.h children_layouter.c children_layouter.h children_layouter_factory.c children_layouter_factory.h clip_board.c clip_board.h dialog.c dialog.h dialog_highlighter.c dialog_highlighter.h dialog_highlighter_factory.c dialog_highlighter_factory.h enums.c enums.h event_queue.c event_queue.h events.c events.h font.c font.h font_loader.c font_loader.h font_manager.c font_manager.h g2d.h glyph_cache.c glyph_cache.h graphic_buffer.c graphic_buffer.h hscrollable.c hscrollable.h idle.c idle.h image_base.c image_base.h image_loader.c image_loader.h image_manager.c image_manager.h input_device_status.c input_device_status.h input_engine.c input_engine.h input_method.c input_method.h keys.h layout.c layout.h layout_def.h lcd.c lcd.h lcd_profile.c lcd_profile.h line_break.c line_break.h locale_info.c locale_info.h main_loop.c main_loop.h native_window.c native_window.h pixel.h pixel_pack_unpack.h self_layouter.c self_layouter.h self_layouter_factory.c self_layouter_factory.h shortcut.c shortcut.h style.c style.h style_const.c style_const.h style_factory.c style_factory.h style_mutable.c style_mutable.h suggest_words.c suggest_words.h system_info.c system_info.h text_edit.c text_edit.h theme.c theme.h timer.c timer.h types_def.h ui_builder.c ui_builder.h ui_feedback.c ui_feedback.h ui_loader.c ui_loader.h velocity.c velocity.h vgcanvas.c vgcanvas.h widget.c widget.h widget_animator.c widget_animator.h widget_animator_factory.h widget_animator_factory_null.c widget_animator_manager.c widget_animator_manager.h widget_consts.h widget_factory.c widget_factory.h widget_vtable.c widget_vtable.h window.c window.h window_animator.c window_animator.h window_animator_factory.c window_animator_factory.h window_base.c window_base.h window_manager.c window_manager.h wuxiaolin.inc
  group awtk-src-blend
    ../../../../../middleware/awtk-1.3/src/blend/: blend_image.inc blend_image_bgr565_bgr565.c blend_image_bgr565_bgr565.h blend_image_bgr565_bgra8888.c blend_image_bgr565_bgra8888.h blend_image_bgr565_rgba8888.c blend_image_bgr565_rgba8888.h blend_image_bgr888_bgr565.c blend_image_bgr888_bgr565.h blend_image_bgr888_bgra8888.c blend_image_bgr888_bgra8888.h blend_image_bgr888_rgba8888.c blend_image_bgr888_rgba8888.h blend_image_bgra8888_bgr565.c blend_image_bgra8888_bgr565.h blend_image_bgra8888_bgra8888.c blend_image_bgra8888_bgra8888.h blend_image_bgra8888_rgba8888.c blend_image_bgra8888_rgba8888.h blend_image_rgb565_bgr565.c blend_image_rgb565_bgr565.h blend_image_rgb565_bgra8888.c blend_image_rgb565_bgra8888.h blend_image_rgb565_rgba8888.c blend_image_rgb565_rgba8888.h blend_image_rgba8888_bgr565.c blend_image_rgba8888_bgr565.h blend_image_rgba8888_bgra8888.c blend_image_rgba8888_bgra8888.h blend_image_rgba8888_rgba8888.c blend_image_rgba8888_rgba8888.h fill_image.inc fill_image_abgr8888.c fill_image_abgr8888.h fill_image_argb8888.c fill_image_argb8888.h fill_image_bgr565.c fill_image_bgr565.h fill_image_bgr888.c fill_image_bgr888.h fill_image_bgra8888.c fill_image_bgra8888.h fill_image_rgb565.c fill_image_rgb565.h fill_image_rgba8888.c fill_image_rgba8888.h image_g2d.c image_g2d.h pixel_ops.inc rotate_image.inc rotate_image_bgr565.c rotate_image_bgr565.h rotate_image_bgr888.c rotate_image_bgr888.h rotate_image_bgra8888.c rotate_image_bgra8888.h rotate_image_rgb565.c rotate_image_rgb565.h rotate_image_rgba8888.c rotate_image_rgba8888.h soft_g2d.c soft_g2d.h stm32_g2d.c
  group awtk-src-clip_board
    ../../../../../middleware/awtk-1.3/src/clip_board/: clip_board_default.c clip_board_default.h
  group awtk-src-compressors
    ../../../../../middleware/awtk-1.3/src/compressors/: compressor_miniz.c compressor_miniz.h
  group awtk-src-dialog_highlighters
    ../../../../../middleware/awtk-1.3/src/dialog_highlighters/: dialog_highlighter_builtins.c dialog_highlighter_builtins.h dialog_highlighter_default.c dialog_highlighter_default.h
  group awtk-src-ext_widgets
    ../../../../../middleware/awtk-1.3/src/ext_widgets/: ext_widgets.c ext_widgets.h
    ../../../../../middleware/awtk-1.3/src/ext_widgets/canvas_widget/: canvas_widget.c canvas_widget.h
    ../../../../../middleware/awtk-1.3/src/ext_widgets/color_picker/: color_component.c color_component.h color_picker.c color_picker.h color_picker_const.h rgb_and_hsv.c rgb_and_hsv.h
    ../../../../../middleware/awtk-1.3/src/ext_widgets/combo_box_ex/: combo_box_ex.c combo_box_ex.h
    ../../../../../middleware/awtk-1.3/src/ext_widgets/features/: draggable.c draggable.h
    ../../../../../middleware/awtk-1.3/src/ext_widgets/gif_image/: gif_image.c gif_image.h
    ../../../../../middleware/awtk-1.3/src/ext_widgets/guage/: guage.c guage.h guage_pointer.c guage_pointer.h
    ../../../../../middleware/awtk-1.3/src/ext_widgets/image_animation/: image_animation.c image_animation.h
    ../../../../../middleware/awtk-1.3/src/ext_widgets/image_value/: image_value.c image_value.h
    ../../../../../middleware/awtk-1.3/src/ext_widgets/keyboard/: candidates.c candidates.h keyboard.c keyboard.h
    ../../../../../middleware/awtk-1.3/src/ext_widgets/mledit/: line_number.c line_number.h mledit.c mledit.h
    ../../../../../middleware/awtk-1.3/src/ext_widgets/mutable_image/: mutable_image.c mutable_image.h
    ../../../../../middleware/awtk-1.3/src/ext_widgets/progress_circle/: progress_circle.c progress_circle.h
    ../../../../../middleware/awtk-1.3/src/ext_widgets/rich_text/: rich_text.c rich_text.h rich_text_node.c rich_text_node.h rich_text_parser.c rich_text_parser.h rich_text_render_node.c rich_text_render_node.h
    ../../../../../middleware/awtk-1.3/src/ext_widgets/scroll_label/: hscroll_label.c hscroll_label.h
    ../../../../../middleware/awtk-1.3/src/ext_widgets/scroll_view/: children_layouter_list_view.c children_layouter_list_view.h list_item.c list_item.h list_view.c list_view.h list_view_h.c list_view_h.h scroll_bar.c scroll_bar.h scroll_view.c scroll_view.h
    ../../../../../middleware/awtk-1.3/src/ext_widgets/slide_menu/: slide_menu.c slide_menu.h
    ../../../../../middleware/awtk-1.3/src/ext_widgets/slide_view/: slide_indicator.c slide_indicator.h slide_view.c slide_view.h
    ../../../../../middleware/awtk-1.3/src/ext_widgets/svg_image/: svg_image.c svg_image.h
    ../../../../../middleware/awtk-1.3/src/ext_widgets/switch/: switch.c switch.h
    ../../../../../middleware/awtk-1.3/src/ext_widgets/text_selector/: text_selector.c text_selector.h
    ../../../../../middleware/awtk-1.3/src/ext_widgets/time_clock/: time_clock.c time_clock.h
  group font_loader
    ../../../../../middleware/awtk-1.3/src/font_loader/: font_loader_bitmap.c font_loader_bitmap.h font_loader_ft.c font_loader_ft.h font_loader_stb.c font_loader_stb.h font_loader_truetype.h
  group graphic_buffer
    ../../../../../middleware/awtk-1.3/src/graphic_buffer/: graphic_buffer_default.c
  group image_loader
    ../../../../../middleware/awtk-1.3/src/image_loader/: image_loader_stb.c image_loader_stb.h
  group input_engines
    ../../../../../middleware/awtk-1.3/src/input_engines/: input_engine_null.c input_engine_null.h input_engine_pinyin.cpp input_engine_pinyin.h
  group input_methods
    ../../../../../middleware/awtk-1.3/src/input_methods/: input_method_creator.c
  group layouters
    ../../../../../middleware/awtk-1.3/src/layouters/: children_layouter_builtins.c children_layouter_builtins.h children_layouter_default.c children_layouter_default.h children_layouter_parser.c self_layouter_builtins.c self_layouter_builtins.h self_layouter_default.c self_layouter_default.h self_layouter_menu.c self_layouter_menu.h self_layouter_parser.c
  group lcd
    ../../../../../middleware/awtk-1.3/src/lcd/: fragment_frame_buffer.h lcd_mem.h lcd_mem.inc lcd_mem_bgr565.c lcd_mem_bgr565.h lcd_mem_bgr888.c lcd_mem_bgr888.h lcd_mem_bgra8888.c lcd_mem_bgra8888.h lcd_mem_fragment.h lcd_mem_fragment.inc lcd_mem_rgb565.c lcd_mem_rgb565.h lcd_mem_rgba8888.c lcd_mem_rgba8888.h lcd_mem_special.c lcd_mem_special.h lcd_mono.c lcd_mono.h lcd_nanovg.c lcd_nanovg.h lcd_reg.h lcd_reg.inc lcd_sdl2.c lcd_sdl2.h lcd_sdl2_mono.c lcd_sdl2_mono.h lcd_vgcanvas.inc
  group main_loop
    ../../../../../middleware/awtk-1.3/src/main_loop/: main_loop_simple.c main_loop_simple.h
  group misc
    ../../../../../middleware/awtk-1.3/src/misc/: new.cpp new.hpp test_cpp.cpp
  group native_window
    ../../../../../middleware/awtk-1.3/src/native_window/: native_window_fb_gl.c native_window_fb_gl.h native_window_raw.c native_window_raw.h native_window_sdl.c native_window_sdl.h
  group platforms
    ../../../../../middleware/awtk-1.3/src/platforms/raw/: cond_var_null.c fs_os.c mutex_null.c sys_tick_handler.c
    ../../../../../middleware/awtk-1.3/src/platforms/common/: rtos.h sys_tick.c
  group streams
    ../../../../../middleware/awtk-1.3/src/streams/buffered/: istream_buffered.c istream_buffered.h ostream_buffered.c ostream_buffered.h
    ../../../../../middleware/awtk-1.3/src/streams/file/: istream_file.c istream_file.h ostream_file.c ostream_file.h
    ../../../../../middleware/awtk-1.3/src/streams/inet/: iostream_tcp.c iostream_tcp.h iostream_udp.c iostream_udp.h istream_tcp.c istream_tcp.h istream_udp.c istream_udp.h ostream_tcp.c ostream_tcp.h ostream_udp.c ostream_udp.h socket_helper.c socket_helper.h
    ../../../../../middleware/awtk-1.3/src/streams/mem/: iostream_mem.c iostream_mem.h istream_mem.c istream_mem.h ostream_mem.c ostream_mem.h
    ../../../../../middleware/awtk-1.3/src/streams/misc/: ostream_retry.c ostream_retry.h
    ../../../../../middleware/awtk-1.3/src/streams/noisy/: iostream_noisy.c iostream_noisy.h ostream_noisy.c ostream_noisy.h
    ../../../../../middleware/awtk-1.3/src/streams/serial/: iostream_serial.c iostream_serial.h istream_serial.c istream_serial.h ostream_serial.c ostream_serial.h serial_helper.c serial_helper.h
    ../../../../../middleware/awtk-1.3/src/streams/shdlc/: iostream_shdlc.c iostream_shdlc.h istream_shdlc.c istream_shdlc.h ostream_shdlc.c ostream_shdlc.h shdlc_helper.c shdlc_helper.h
    ../../../../../middleware/awtk-1.3/src/streams/tools/: serial_at.c serial_echo.c serial_send.c shdlc_recv.c shdlc_send.c udp_recv.c udp_send.c
  group svg
    ../../../../../middleware/awtk-1.3/src/svg/: bsvg.c bsvg.h bsvg_builder.c bsvg_builder.h bsvg_common.h bsvg_draw.c bsvg_draw.h bsvg_to_svg.c bsvg_to_svg.h svg_path.c svg_path.h svg_path_parser.c svg_path_parser.h svg_shape.c svg_shape.h svg_to_bsvg.c svg_to_bsvg.h
  group tkc
    ../../../../../middleware/awtk-1.3/src/tkc/: asset_info.h buffer.c buffer.h color.c color.h color_parser.c color_parser.h compressor.c compressor.h cond_var.h crc.c crc.h darray.c darray.h date_time.c date_time.h easing.c easing.h emitter.c emitter.h endian.h event.c event.h event_source.c event_source.h event_source_fd.c event_source_fd.h event_source_idle.c event_source_idle.h event_source_manager.c event_source_manager.h event_source_manager_default.c event_source_manager_default.h event_source_timer.c event_source_timer.h expr_eval.c expr_eval.h fs.c fs.h func_call_parser.c func_call_parser.h func_desc.h idle_info.c idle_info.h idle_manager.c idle_manager.h int_str.c int_str.h iostream.c iostream.h istream.c istream.h matrix.c matrix.h mem.c mem.h mime_types.h mutex.h named_value.c named_value.h object.c object.h object_array.c object_array.h object_default.c object_default.h ostream.c ostream.h path.c path.h platform.h rect.c rect.h ring_buffer.c ring_buffer.h rom_fs.c rom_fs.h semaphore.h slist.c slist.h socket_pair.c socket_pair.h str.c str.h str_str.c str_str.h stream_const.h thread.h time_now.c time_now.h timer_info.c timer_info.h timer_manager.c timer_manager.h tokenizer.c tokenizer.h types_def.h utf8.c utf8.h utils.c utils.h value.c value.h value_desc.c value_desc.h wstr.c wstr.h log.c log.h
  group ubjson
    ../../../../../middleware/awtk-1.3/src/ubjson/: ubjson_const.h ubjson_parser.c ubjson_parser.h ubjson_reader.c ubjson_reader.h ubjson_writer.c ubjson_writer.h
  group ui_loader
    ../../../../../middleware/awtk-1.3/src/ui_loader/: ui_binary_writer.c ui_binary_writer.h ui_builder_default.c ui_builder_default.h ui_loader_default.c ui_loader_default.h ui_loader_xml.c ui_loader_xml.h ui_serializer.c ui_serializer.h ui_xml_writer.c ui_xml_writer.h window_open.c
  group vgcanvas
    ../../../../../middleware/awtk-1.3/src/vgcanvas/: texture.inc vgcanvas_cairo.c vgcanvas_nanovg.inc vgcanvas_nanovg_bgfx.c vgcanvas_nanovg_bgfx.inc vgcanvas_nanovg_gl.c vgcanvas_nanovg_gl.inc vgcanvas_nanovg_soft.c vgcanvas_nanovg_soft.inc vgcanvas_null.c
  group widget_animators
    ../../../../../middleware/awtk-1.3/src/widget_animators/: widget_animator_factory.c widget_animator_move.h widget_animator_opacity.h widget_animator_prop.c widget_animator_prop.h widget_animator_prop2.c widget_animator_prop2.h widget_animator_rotation.h widget_animator_scale.h widget_animator_scroll.c widget_animator_scroll.h widget_animator_value.h
  group widgets
    ../../../../../middleware/awtk-1.3/src/widgets/: app_bar.c app_bar.h button.c button.h button_group.c button_group.h calibration_win.c calibration_win.h check_button.c check_button.h color_tile.c color_tile.h column.c column.h combo_box.c combo_box.h combo_box_item.c combo_box_item.h dialog_client.c dialog_client.h dialog_helper.c dialog_title.c dialog_title.h digit_clock.c digit_clock.h dragger.c dragger.h edit.c edit.h grid.c grid.h grid_item.c grid_item.h group_box.c group_box.h image.c image.h label.c label.h overlay.c overlay.h pages.c pages.h popup.c popup.h progress_bar.c progress_bar.h row.c row.h slider.c slider.h spin_box.c spin_box.h system_bar.c system_bar.h tab_button.c tab_button.h tab_button_group.c tab_button_group.h tab_control.c tab_control.h view.c view.h widgets.c widgets.h
  group window_animators
    ../../../../../middleware/awtk-1.3/src/window_animators/: window_animator_builtins.c window_animator_builtins.h window_animator_center_scale.c window_animator_center_scale.h window_animator_common.c window_animator_common.h window_animator_fade.c window_animator_fade.h window_animator_htranslate.c window_animator_htranslate.h window_animator_popdown.c window_animator_popdown.h window_animator_popup.c window_animator_popup.h window_animator_slide.c window_animator_slide.h window_animator_slide_down.c window_animator_slide_down.h window_animator_slide_left.c window_animator_slide_left.h window_animator_slide_right.c window_animator_slide_right.h window_animator_slide_up.c window_animator_slide_up.h window_animator_vtranslate.c window_animator_vtranslate.h
  group window_manager
    ../../../../../middleware/awtk-1.3/src/window_manager/: window_manager_default.c window_manager_default.h window_manager_simple.c window_manager_simple.h
  group xml
    ../../../../../middleware/awtk-1.3/src/xml/: xml_builder.c xml_builder.h xml_parser.c xml_parser.h
  group awtk-3rd-agge
    ../../../../../middleware/awtk-1.3/3rd/agge/agge/: bitmap.h blender_linear_gradient.h blender_radial_gradient.h blenders_generic.h clipper.h config.h filling_rules.h math.cpp math.h memory.h path.h pixel.h pixel_a.h pixel_convert.h pixel_set_a.h pod_vector.h precise_delta.h rasterizer.h renderer.h scanline.h stroke.cpp stroke.h stroke_features.cpp stroke_features.h tools.h types.h vector_rasterizer.cpp vector_rasterizer.h vertex_sequence.h
  group awtk-3rd-gpinyin-src
    ../../../../../middleware/awtk-1.3/3rd/gpinyin/src/: dictlist.cpp dicttrie.cpp gpinyin.inc lpicache.cpp matrixsearch.cpp mystdlib.cpp ngram.cpp pinyinime.cpp searchutility.cpp spellingtrie.cpp splparser.cpp utf16char.cpp
  group awtk-3rd-nanovg-agge
    ../../../../../middleware/awtk-1.3/3rd/nanovg/agge/: nanovg_agge.cpp nanovg_agge.h nanovg_image_blender.h nanovg_vertex.cpp nanovg_vertex.h raw_bitmap.h
    ../../../../../middleware/awtk-1.3/3rd/nanovg/base/: fontstash.h nanovg.c nanovg.h stb_image.h stb_truetype.h
  group awtk-3rd-libunibreak
    ../../../../../middleware/awtk-1.3/3rd/libunibreak/: emojidata.inc emojidef.c emojidef.h graphemebreak.c graphemebreak.h graphemebreakdata.inc graphemebreakdef.h linebreak.c linebreak.h linebreakdata.c linebreakdef.c linebreakdef.h unibreakbase.c unibreakbase.h unibreakdef.c unibreakdef.h wordbreak.c wordbreak.h wordbreakdata.inc wordbreakdef.h
  group awtk-port
    ../awtk-port/: awtk_config.h main_loop_easyarm_rt1052_raw.c platform.c
  group awtk-demo
    ../Chart-Demo/src/: app_main.c window_bar_series.c window_line_series.c window_main.c window_meter.c window_pie.c window_series_common.c
    ../Chart-Demo/src/custom_widgets/: custom_widgets.c custom_widgets.h
    ../Chart-Demo/src/custom_widgets/base/: fifo.c fifo.h wuxiaolin_draw_line.inc
    ../Chart-Demo/src/custom_widgets/chart/: axis.c axis.h axis_p.c axis_p.h axis_types.h bar_series.c bar_series.h chart_animator.c chart_animator.h chart_utils.c chart_utils.h chart_view.c chart_view.h line_series.c line_series.h series.c series.h series_p.c series_p.h series_types.h tooltip.c tooltip.h tooltip_types.h x_axis.c x_axis.h y_axis.c y_axis.h
    ../Chart-Demo/src/custom_widgets/pie_slice/: pie_slice.c pie_slice.h
  group awtk-3rd-miniz
    ../../../../../middleware/awtk-1.3/3rd/miniz/: miniz.c miniz.h miniz_common.h miniz_export.h miniz_tdef.c miniz_tdef.h miniz_tinfl.c miniz_tinfl.h miniz_zip.c miniz_zip.h
target emwin_gui_demo flexspi_nor_sdram_debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: emwin_gui_demo.out
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, XIP_BOOT_HEADER_DCD_ENABLE=1, SKIP_SYSCLK_INIT, DEBUG, CPU_MIMXRT1052DVL6B, HAS_AWTK_CONFIG,MINIZ_NO_STDIO
  c misc: --library_interface=armcc --diag_suppress=66,1296,186 --diag_suppress=1296,186 --gnu
  c include: ..;../../..;../../../../../CMSIS/Include;../../../../../devices;../../../../../middleware/emwin/emWin_Config;../../../../../middleware/emwin/emWin_header;../../../../../devices/MIMXRT1052/drivers;../../../../../devices/MIMXRT1052/drivers;../../../../../devices/MIMXRT1052/drivers;../../../../../components/ft5406_rt;../../../../../devices/MIMXRT1052/drivers;../../../../../devices/MIMXRT1052/drivers;../../../../../devices/MIMXRT1052;../../../../../devices/MIMXRT1052/utilities/str;../../../../../devices/MIMXRT1052/utilities/debug_console;../../../../../components/uart;../../../../../components/serial_manager;../../../../../components/serial_manager;../../../../../devices/MIMXRT1052/drivers;../../../../../components/lists;../../../../../devices/MIMXRT1052/drivers;../../../../../devices/MIMXRT1052/drivers;../../../../../devices/MIMXRT1052/xip;../../../xip;..\..\..\..\..\middleware\awtk-1.3;..\..\..\..\..\middleware\awtk-1.3\src;..\..\..\..\..\middleware\awtk-1.3\src\ext_widgets;..\..\..\..\..\middleware\awtk-1.3\3rd;..\..\..\..\..\middleware\awtk-1.3\3rd\agge;..\..\..\..\..\middleware\awtk-1.3\3rd\nanovg;..\..\..\..\..\middleware\awtk-1.3\3rd\nanovg\base;..\..\..\..\..\middleware\awtk-1.3\3rd\nanovg\gl;..\..\..\..\..\middleware\awtk-1.3\3rd\nanovg\bgfx;..\..\..\..\..\middleware\awtk-1.3\3rd\gpinyin\include;..\..\..\..\..\middleware\awtk-1.3\3rd\libunibreak;..\awtk-port;..\Chart-Demo
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1052xxxxx_flexspi_nor_sdram.scf
  link misc: --remove --keep=*(.boot_hdr.ivt) --keep=*(.boot_hdr.boot_data) --keep=*(.boot_hdr.dcd_data) --keep=*(.boot_hdr.conf) --predefine="-DXIP_BOOT_HEADER_ENABLE=1"
target emwin_gui_demo sdram_release (ARM-ADS)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: emwin_gui_demo.out
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: SKIP_SYSCLK_INIT, NDEBUG, CPU_MIMXRT1052DVL6B
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1052xxxxx_sdram.scf
  link misc: as above
target emwin_gui_demo flexspi_nor_sdram_release (ARM-ADS)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: emwin_gui_demo.out
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, XIP_BOOT_HEADER_DCD_ENABLE=1, SKIP_SYSCLK_INIT, NDEBUG, CPU_MIMXRT1052DVL6B
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1052xxxxx_flexspi_nor_sdram.scf
  link misc: ../../../../../middleware/emwin/emWin_library/Keil/emWin_M4F.lib --remove --keep=*(.boot_hdr.ivt) --keep=*(.boot_hdr.boot_data) --keep=*(.boot_hdr.dcd_data) --keep=*(.boot_hdr.conf) --predefine="-DXIP_BOOT_HEADER_ENABLE=1"
